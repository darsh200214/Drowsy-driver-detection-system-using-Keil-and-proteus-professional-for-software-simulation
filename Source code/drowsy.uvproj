# Keil uVision project drowsy.uvproj, settings and files
target Target (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: drowsy +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 drowsy.c
